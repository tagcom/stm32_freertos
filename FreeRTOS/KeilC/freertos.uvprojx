# Keil uVision project freertos.uvprojx, settings and files
target freertos (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\StdPeriph_Lib_V1.8.0\CMSIS\Include;..\StdPeriph_Lib_V1.8.0\CMSIS\Device\ST\STM32F4xx\Include;..\User;..\StdPeriph_Lib_V1.8.0\STM32F4xx_StdPeriph_Driver\inc;..\FreeRTOSv9.0.0\Source\include;..\FreeRTOSv9.0.0\Source\portable\Keil
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c
  group Startup
    ../User/: system_stm32f4xx.c
    ../StdPeriph_Lib_V1.8.0/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group StdPeriph_Driver
    ../StdPeriph_Lib_V1.8.0/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c
  group FreeRTOS/source
    ../FreeRTOSv9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/portable
    ../FreeRTOSv9.0.0/Source/portable/Keil/: port.c
    ../FreeRTOSv9.0.0/Source/portable/MemMang/: heap_4.c
